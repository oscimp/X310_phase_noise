options:
  parameters:
    author: edecoux
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: phase_noise
    output_language: python
    title: Phase noise
  states: {}

blocks:
- name: magnitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.00001'
    stop: '6'
    value: '0'
  states: {state: disabled}
- name: magnitude
  id: variable
  parameters:
    value: '0.025'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: magnitude
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: magnitude
  id: parameter
  parameters:
    short_id: m
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: 200e6
    clock_source0: external
    comment: |-
      N210: addr=192.168.42.2
      B210: type=b200
    dev_addr: ''
    dev_args: type=b200
    gain0: '79'
    samp_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', analog_phase_modulator_fc_0, '0']
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
